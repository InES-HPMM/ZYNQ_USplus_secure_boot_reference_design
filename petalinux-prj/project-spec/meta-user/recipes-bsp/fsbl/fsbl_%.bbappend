#Add debug for FSBL
XSCTH_BUILD_DEBUG = "1"

#Add compiler flags for FSBL
YAML_COMPILER_FLAGS_append = " -DFSBL_DEBUG_DETAILED"
