#Add compiler flags for PMUFW
YAML_COMPILER_FLAGS_append = " -DXPFW_DEBUG_DETAILED -DENABLE_PM -DENABLE_SECURE -DENABLE_SECURE_ACCESS"
